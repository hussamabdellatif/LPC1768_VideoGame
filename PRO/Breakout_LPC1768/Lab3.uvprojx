# Keil uVision project Lab3.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lab3
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: Font_6x8_h.h Font_16x24_h.h Font_24x16.h GLCD.h GLCD_LPC1700.c GLCD_UTILS.c GLCD_UTILS.h Lab3.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
